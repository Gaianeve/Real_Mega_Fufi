Commit message: Update PIPPA_oneleg_no_joint.urdf

File: Robot/1LegTrail/PIPPA_oneleg_no_joint.urdf (robot description, URDF)
Before this commit: robot PIPPA_oneleg, 3 links, 2 joints
Links:
- removed link Giunto_Link
Joints:
- removed joint Gamba_Link_joint
- removed joint Giunto_Link_joint
