Commit message: Update PIPPA_oneleg_with_ground.urdf

File: Robot/1LegTrail/PIPPA_oneleg_with_ground.urdf (robot description, URDF)
Before this commit: robot PIPPA_oneleg, 4 links, 3 joints
Joints:
- joint Colonna_Scatola_joint: origin xyz=0 0 0.25 rpy=0 0 0 -> xyz=0 0 0.5 rpy=0 0 0
